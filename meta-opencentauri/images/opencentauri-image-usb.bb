require opencentauri-image-base.bb

DESCRIPTION = "Cosmos-Nebula USB Image"
LICENSE = "GPL-3.0-only"

IMAGE_FEATURES += "package-management"

WKS_FILES = "opencentauri-usb-image.wks.in"
